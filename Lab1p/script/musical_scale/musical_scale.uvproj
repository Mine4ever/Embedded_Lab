# Keil uVision project musical_scale.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: musical_scale +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: musical_scale.asm
    C:/Users/93595/Desktop/: 5.ASM
